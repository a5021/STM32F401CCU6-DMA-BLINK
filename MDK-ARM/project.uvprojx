# Keil uVision project project.uvprojx, settings and files
target Debug (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=2
  c define: STM32F401xC
  c misc: -Wextra -Wpedantic
  c include: ./inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group src
    ../src/: main.c
target Release (6180000::V6.18::ARMCLANG)
  device: STM32F401CCUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: as above
  output: Project +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 v6Lto=1 wLevel=2
  c define: STM32F401xC
  c misc: -Wextra -Wpedantic
  c include: ./inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
